File: LEDSphere/rx_coil.kicad_sch (KiCad schematic)
At the start: 13 parts

Commit message: Arrange file structure
Parts:
- U103, U104: value ~ -> (none)
